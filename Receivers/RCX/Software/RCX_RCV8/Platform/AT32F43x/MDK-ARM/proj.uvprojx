# Keil uVision project proj.uvprojx, settings and files
target RCX_RCV8 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F435CGU7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.1.1
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARDUINO=111
  c misc: --gnu --diag_warning=4017
  c include: ..\..\..\Application;..\..\..\ArduinoAPI;..\..\..\Libraries;..\Core;..\Config
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x60000
  group Application
    ../../../Application/: main.cpp rt_sys.cpp ComBasic.cpp CommonMacro.h ComPrivate.h FileGroup.h Handle_Ctrl.cpp Handle_LED.cpp Handle_Passback.cpp Handle_System.cpp SysConfig.h
  group Config
    ../Config/: mcu_config.h
  group RCX
    ../../../Libraries/RCX/: crc.cpp crc.h RCX.h RCX_Channel.cpp RCX_ChannelDef.h RCX_Config.h RCX_Handshake.h RCX_RxPackage.cpp RCX_TxPackage.cpp RCX_Type.h
    ../../../Libraries/RCX/Slaver/: RCX_Handshake.cpp
  group NRF
    ../../../Libraries/NRF/: NRF.h NRF_Basic.cpp NRF_FHSS.cpp NRF_Reg.h NRF_TRM.cpp
  group Libraries
    ../../../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../../../Libraries/Servo/: Servo.cpp
  group ArduinoAPI
    ../../../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp Stream.cpp Tone.cpp Wire.cpp WireBase.cpp WMath.cpp WString.cpp
  group Core
    ../Core/: mcu_type.h mcu_core.h mcu_core.c at32f435_437_clock.c adc.c delay.c dwt.c exti.c gpio.c timer.c pwm.c rtc.c HardwareSerial.cpp SPI.cpp wdg.c
  group README
    ../../../: README.md
software components: CMSIS:CORE 5.5.0, Device:Startup 2.0.0, Device:at32f435_437_conf 2.0.0, Device:at32f435_437_firmware_library:adc 2.0.0, Device:at32f435_437_firmware_library:crm 2.0.0, Device:at32f435_437_firmware_library:dma 2.0.0, Device:at32f435_437_firmware_library:ertc 2.0.0, Device:at32f435_437_firmware_library:exint 2.0.0, Device:at32f435_437_firmware_library:gpio 2.0.0, Device:at32f435_437_firmware_library:misc 2.0.0, Device:at32f435_437_firmware_library:pwc 2.0.0, Device:at32f435_437_firmware_library:scfg 2.0.0, Device:at32f435_437_firmware_library:spi 2.0.0, Device:at32f435_437_firmware_library:tmr 2.0.0, Device:at32f435_437_firmware_library:usart 2.0.0, Device:at32f435_437_firmware_library:wdt 2.0.0
