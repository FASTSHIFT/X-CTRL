# Keil uVision project Pro.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\NRF;..\Libraries\Adafruit_GFX_Library;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\XFS;..\Libraries\FifoQueue;.\Handle;..\Libraries\LightGUI;..\Libraries\LightGUI\Engine3D;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer;..\Libraries\BV_Player;..\Libraries\SD\src;..\Libraries\SoftwareSPI;..\Libraries\lua-5.3.2\src;.\LuaCtrl;..\Libraries\StrPrinter;..\Libraries\TFT_S6B33B2;..\Libraries\ShellClient;..\Libraries\Filters
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/StrPrinter/: StrPrinter.cpp
    ../Libraries/TFT_S6B33B2/: TFT_S6B33B2.cpp
    ../Libraries/ShellClient/: ShellClient.cpp
    ../Libraries/NRF/: SoftwareSPI.cpp NRF.cpp
    ../Libraries/Filters/: Filters.cpp
    ./: Buttons.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c timer.c
    ../CORE/: delay.c pwm.c
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp
    ./: NRFClient.cpp
  group GUI
    ./: DisplayFunctions.cpp Page_Ctrl.cpp Page_Main.cpp
    ./GUI/: DisplayBasic.cpp Page_EXAMPLE.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_DataStorage.cpp Handle_EncoderEvent.cpp Handle_SD.cpp
  group FileSystem
    ../Libraries/SD/src/: SD.cpp File.cpp
    ../Libraries/SD/src/utility/: SdVolume.cpp SdFile.cpp Sd2Card.cpp
target Arduino (ARM-ADS)
  device: STM32F103TB STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;..\Libraries\MusicPlay;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\PageManager;..\Libraries\MenuManager
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:USART 1.3.0
