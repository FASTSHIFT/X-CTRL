# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: .\RTE;.\RTE\Device\STM32F103C8;..\USER;..\Drivers\utility;..\ArduinoAPI;..\Core;..\Libraries;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_and_ST7789_Library;..\Libraries\MillisTaskManager;..\Libraries\NRF;..\Libraries\DigitalFilter;..\Libraries\I2Cdev;..\Libraries\MPU6050;.\GUI;..\Libraries\ButtonEvent;..\..\TriggerCtrl
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp SPI.cpp Tone.cpp WMath.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp Adafruit_SPITFT.cpp
    ../Libraries/Adafruit_ST7735_and_ST7789_Library/: Adafruit_ST7735.cpp Adafruit_ST77xx.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/DigitalFilter/: DigitalFilter.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group USER
    ./: main.cpp ButtonEvent_Handler.cpp Communicate.cpp SensorRead.cpp Initialization.cpp
  group Module
    ./: MPU6050_Handler.cpp
  group GUI
    ./GUI/: PageManager.cpp GUI_Widget.cpp Page_CtrlInfo.cpp Page_MainMenu.cpp
    ./: Boot_animation.cpp Bitmap.h Page_Option.cpp
  group Tone
    ./: Tone frequency.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
