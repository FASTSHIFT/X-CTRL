# Keil uVision project X-CTRL.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: X-CTRL
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DERIVER,ARDUINO=111
  c misc: --gnu
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\XFS;..\Libraries\FifoQueue;.\Handle;..\Libraries\LightGUI;..\Libraries\LightGUI\Engine3D;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp ComBasic.cpp ComHandshake.cpp
  group GUI
    ./GUI/: DisplayBasic.cpp DisplayStatusBar.cpp DrawBitmap.cpp Page_EXAMPLE.cpp Page_MainMenu.cpp Page_CtrlInfo.cpp Page_Options.cpp Page_SetJoystick.cpp Page_SetBluetooth.cpp Page_SetGravity.cpp Page_About.cpp Page_Handshake.cpp Page_FreqGraph.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_DataStorage.cpp Handle_EncoderEvent.cpp Handle_HMI.cpp Handle_MPU6050.cpp Handle_PowerCtrl.cpp Handle_XFS.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7735_Library/: Adafruit_ST7735.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/LightGUI/Engine3D/: Engine3D.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/XFS/: XFS.cpp
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c timer.c
    ../CORE/: delay.c pwm.c
target Arduino (ARM-ADS)
  device: STM32F103TB STMicroelectronics
  cpu: as above
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;..\Libraries\MusicPlay;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\PageManager;..\Libraries\MenuManager
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
