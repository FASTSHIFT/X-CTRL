# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: .\RTE;.\RTE\Device\STM32F103C8;..\USER;..\Drivers\utility;..\ArduinoAPI;..\Core;..\Libraries;.\RC_Ctrl;..\Libraries\I2Cdev;..\Libraries\LiquidCrystal_I2C;..\Libraries\MPU6050;..\Libraries\NRF;..\Libraries\SSD1306_I2C
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp SPI.cpp Tone.cpp WMath.cpp
  group Libraries
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/LiquidCrystal_I2C/: LiquidCrystal_I2C.cpp
    ../Libraries/SSD1306_I2C/: SSD1306_I2C.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group USER
    ./: main.cpp
  group RC_Ctrl
    ./RC_Ctrl/: RC_Ctrl.cpp BlueToothSetup.cpp BuzzRing.cpp Calibration.cpp DataProcess.cpp DataStorage.cpp Display_MainScreen.cpp Display_OtherScreen.cpp Joystick_Key_Read.cpp LoadCtrlMode.cpp Math.cpp MENU.cpp MPU6050.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
