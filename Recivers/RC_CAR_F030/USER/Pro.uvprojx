# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030F4 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030F4P6,STM32F030
  c include: .\RTE;..\USER;..\Drivers\utility;..\ArduinoAPI;..\Core;..\Libraries;.\RTE\Device\STM32F030C8;..\Core\STM32F0xx_StdPeriph_Driver\inc;..\Core\STM32F0xx_StdPeriph_Driver\src;.\RTE\Device\STM32F030F4;.\RTE\Device\STM32F030RC;.\RTE\_Project;..\Libraries\NRF;..\Libraries\Servo;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\I2Cdev;..\Libraries\MPU6050
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c Print.cpp itoa.c HardwareSerial.cpp Stream.cpp WString.cpp WireBase.cpp Wire.cpp WMath.cpp Tone.cpp SPI.cpp
  group Libraries
    ../Libraries/Servo/: Servo.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/DigitalFilter/: DigitalFilter.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c usart.c
    ../CORE/: delay.c
  group USER
    ./: main.cpp DataProcess.cpp CarCtrl.cpp
  group StdPeriph_Driver
    ../Core/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group Startup
    ./CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
  group CMSIS
    ./: system_stm32f0xx.c
software components: CMSIS:CORE 5.1.1
