# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_SSD1306;..\Libraries\MPU6050;..\Libraries\LiquidCrystal_I2C;..\Libraries\I2Cdev;..\Libraries\MillisTaskManager;..\Libraries\NRF;..\Libraries\ButtonEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\DigitalFilter;..\Libraries\EEPROM;.\BASIC;.\Handler;..\Libraries\MusicPlay
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp SPI.cpp Tone.cpp WMath.cpp
  group Libraries
    ../Libraries/Adafruit_SSD1306/: Adafruit_SSD1306.cpp
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/DigitalFilter/: DigitalFilter.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/MusicPlay/: MusicPlay.cpp
    ../Libraries/NRF/: NRF.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group BASIC
    ./BASIC/: main.cpp Initialize.cpp Communicate.cpp SensorRead.cpp
  group GUI
    ./GUI/: GUI_Display.cpp GUI_DrawBitmap.cpp GUI_Widget.cpp GUI_StatusBar.cpp PageManager.cpp Page_About.cpp Page_CtrlInfo.cpp Page_MainMenu.cpp Page_Options.cpp Page_SetBluetooth.cpp Page_SetGravity.cpp Page_SetJoystick.cpp
  group Handler
    ./Handler/: ButtonEvent_Handler.cpp Buzz_Handler.cpp EEPROM_Handler.cpp HMI_Handler.cpp MPU6050_Handler.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
