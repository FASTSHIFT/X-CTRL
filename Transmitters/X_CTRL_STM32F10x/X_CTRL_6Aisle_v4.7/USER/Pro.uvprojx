# Keil uVision project Pro.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\NRF;..\Libraries\Adafruit_GFX_Library;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\ButtonEvent;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\FifoQueue;.\Handle;..\Libraries\LightGUI;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer;..\Libraries\Adafruit_SSD1306
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_SSD1306/: Adafruit_SSD1306.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c timer.c
    ../CORE/: delay.c pwm.c
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp ComBasic.cpp ComHandshake.cpp
  group GUI
    ./GUI/: DisplayBasic.cpp DisplayStatusBar.cpp Page_EXAMPLE.cpp Page_MainMenu.cpp Page_CtrlInfo.cpp Page_Options.cpp Page_SetJoystick.cpp Page_About.cpp Page_Handshake.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_DataStorage.cpp Handle_EncoderEvent.cpp
target Arduino (ARM-ADS)
  device: STM32F103TB STMicroelectronics
  cpu: as above
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;..\Libraries\MusicPlay;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\PageManager;..\Libraries\MenuManager
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
