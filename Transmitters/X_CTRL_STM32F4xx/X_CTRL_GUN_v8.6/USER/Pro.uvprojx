# Keil uVision project Pro.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,HSE_VALUE=8000000
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\NRF;..\Libraries\Adafruit_GFX_Library;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\XFS;..\Libraries\FifoQueue;.\Handle;..\Libraries\LightGUI;..\Libraries\LightGUI\Engine3D;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer;..\Libraries\TFT_SSD1283A;..\Libraries\BV_Player;..\Libraries\SD\src;..\Libraries\SoftwareSPI;..\Libraries\lua-5.3.2\src;.\LuaCtrl;..\Libraries\StrPrinter;.\Game\hopper;..\Libraries\Arduboy;..\Libraries\WavDecoder;..\Libraries\LuaScript;..\Libraries\cm_backtrace;.\Game\doom-nano
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/TFT_SSD1283A/: TFT_SSD1283A.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/BV_Player/: BV_Player.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/SoftwareSPI/: SoftwareSPI.cpp
    ../Libraries/StrPrinter/: StrPrinter.cpp
    ../Libraries/XFS/: XFS.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/WavDecoder/: wav_decoder.cpp
    ../Libraries/LuaScript/: LuaScript.cpp
    ../Libraries/cm_backtrace/: cm_backtrace.c
    ../Libraries/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group Core
    ../Core/: adc.c exti.c gpio.c timer.c rng.c
    ../CORE/: delay.c pwm.c
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp ComBasic.cpp ComHandshake.cpp
  group GUI
    ./GUI/: DisplayBasic.cpp DisplayStatusBar.cpp DrawBitmap.cpp Page_EXAMPLE.cpp Page_CtrlInfo.cpp Page_MainMenu.cpp Page_MainMenuDymanic.cpp Page_Options.cpp Page_SetJoystick.cpp Page_SetBluetooth.cpp Page_SetGravity.cpp Page_About.cpp Page_GameDoom.cpp Page_GameHopper.cpp Page_Handshake.cpp Page_FreqGraph.cpp Page_FileExplorer.cpp Page_BvPlayer.cpp Page_WavPlayer.cpp Page_LuaScript.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_BvPlayer.cpp Handle_DataStorage.cpp Handle_HMI.cpp Handle_EncoderEvent.cpp Handle_KeyboardSim.cpp Handle_Motor.cpp Handle_MPU6050.cpp Handle_SD.cpp Handle_XFS.cpp Handle_XBox360Sim.cpp
  group FileSystem
    ../Libraries/SD/src/: SD.cpp File.cpp
    ../Libraries/SD/src/utility/: SdVolume.cpp SdFile.cpp Sd2Card.cpp
  group lua-5.3.2
    ../Libraries/lua-5.3.2/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group LuaCtrl
    ./LuaCtrl/: LuaBasic.cpp LuaCom.cpp LuaGUI.cpp LuaGPIO.cpp LuaModuleCtrl.cpp LuaMouseKeyboard.cpp LuaTime.cpp
  group Arduboy
    ../Libraries/Arduboy/: Arduboy.cpp
    ../Libraries/Arduboy/audio/: audio.cpp
    ../Libraries/Arduboy/core/: core.cpp
  group Game/Hopper
    ./Game/hopper/: game.cpp hopper.cpp logo.cpp MyArduboy.cpp title.cpp
  group Game/doom-nano
    ./Game/doom-nano/: doom-nano.cpp entities.cpp input.cpp types.cpp
  group README
    ./: UpgradeLogs.txt
    ../: README.txt
target Arduino (ARM-ADS)
  device: STM32F103TB STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;..\Libraries\MusicPlay;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\PageManager;..\Libraries\MenuManager
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:USART 1.3.0
