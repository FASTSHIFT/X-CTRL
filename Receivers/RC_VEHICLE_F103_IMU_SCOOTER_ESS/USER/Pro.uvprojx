# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\MillisTaskManager;..\Libraries\Servo;..\Libraries\NRF;.\Basic;.\Handle;..\Libraries\EEPROM;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\Filters
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp SPI.cpp Stream.cpp Tone.cpp
  group Libraries
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/Filters/: Filters.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/Servo/: Servo.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group Basic
    ./Basic/: main.cpp Initialization.cpp ComBasic.cpp ComHandshake.cpp
  group Handle
    ./Handle/: Handle_MPU6050.cpp Handle_DataStorage.cpp Handle_LED.cpp Handle_Ctrl.cpp Handle_Speed.cpp Handle_SpeedDet.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
