# Keil uVision project Pro.uvprojx, settings and files
target X_CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: .\RTE;.\RTE\Device\STM32F103C8;..\USER;..\Drivers\utility;..\ArduinoAPI;..\Core;..\Libraries;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\EEPROM_SaveFloat;..\Libraries\extEEPROM;..\Libraries\NRF;..\Libraries\SSD1306_I2C;..\Libraries\Adafruit_GFX_Library;..\Libraries\Adafruit_ST7735_Library;..\Libraries\MillisTaskManager;..\Libraries\Bezier;..\Libraries\DigitalFilter;..\Libraries\BottonEvent;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Libraries
    ../Libraries/extEEPROM/: extEEPROM.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7735_Library/: Adafruit_ST7735.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/Bezier/: BezierLine.cpp
    ../Libraries/DigitalFilter/: DigitalFilter.cpp
    ../Libraries/BottonEvent/: BottonEvent.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
  group Core
    ../CORE/: delay.c pwm.c
    ../Core/: gpio.c adc.c exti.c timer.c
  group USER
    ./: main.cpp Initialization.cpp SensorRead.cpp Communicate.cpp BottonEvent_Handler.cpp EncoderEvent_Handler.cpp
  group GUI
    ./GUI/: GUI_Widget.cpp GUI_Display.cpp GUI_DrawBitmap.cpp
  group Module
    ./: BlueTooth_Handler.cpp BuzzRing.cpp MPU6050_Handler.cpp
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
