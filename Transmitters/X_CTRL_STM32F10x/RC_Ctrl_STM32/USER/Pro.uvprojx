# Keil uVision project Pro.uvprojx, settings and files
target RC_Ctrl (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Pro +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER
  c include: .\RTE;.\RTE\Device\STM32F103C8;..\USER;..\Program;..\Drivers;..\CORE
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Program
    ../Program/: JS_KEY_READ.c Arduino.c DATA_Process.c main.cpp
  group Drivers
    ../Drivers/: NRF.cpp SoftIIC.cpp DS18B20_S.cpp dht11.cpp MusicCode.cpp Adafruit_PWMServoDriver.cpp DS1302.cpp
  group CORE
    ../CORE/: ADC.c delay.c GPIO.c sys.c usart.c exit.c time_exit.c
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
