# Keil uVision project X-CTRL.uvprojx, settings and files
target X-CTRL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: X-CTRL_GUN
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,ARDUINO=111,HSE_VALUE=8000000,PLL_M=8
  c misc: --gnu
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\NRF;..\Libraries\Adafruit_GFX_Library;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;..\Libraries\EEPROM;..\Libraries\EEPROM_File;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\XFS;..\Libraries\FifoQueue;..\Libraries\LightGUI;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer;..\Libraries\TFT_SSD1283A;..\Libraries\BV_Player;..\Libraries\SoftwareSPI;..\Libraries\lua-5.3.2\src;..\Libraries\StrPrinter;..\Libraries\Arduboy;..\Libraries\WavDecoder;..\Libraries\cm_backtrace;..\Libraries\SdFat\src;.\Game\hopper;.\Game\doom-nano;.\GUI;.\GUI\Bitmap;.\Handler;.\Basic;.\Handle;.\LuaScript;.\Communication
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp sys_io.cpp system.c SysConfig.h
  group Communication
    ./Communication/: ComPrivate.h ComBasic.cpp ComPassback.cpp
  group Communication/RCX
    ./Communication/RCX/: RCX_Config.h RCX.h RCX_Channel.cpp RCX_Handshake.h RCX_TxPackage.cpp RCX_RxPackage.cpp crc.cpp
    ./Communication/RCX/Master/: RCX_Handshake.cpp
  group GUI
    ./GUI/: DisplayPrivate.h DisplayBasic.cpp DisplayStatusBar.cpp DrawBitmap.cpp Page_EXAMPLE.cpp Page_About.cpp Page_BvPlayer.cpp Page_ChannelCfg.cpp Page_CtrlInfo.cpp Page_FileExplorer.cpp Page_FreqGraph.cpp Page_GameDoom.cpp Page_GameHopper.cpp Page_Handshake.cpp Page_Jamming.cpp Page_LuaScript.cpp Page_MainMenu.cpp Page_MainMenuDymanic.cpp Page_Options.cpp Page_SetJoystick.cpp Page_SetBluetooth.cpp Page_SetGravity.cpp Page_WavPlayer.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_BvPlayer.cpp Handle_DataStorage.cpp Handle_EncoderEvent.cpp Handle_KeyboardSim.cpp Handle_Motor.cpp Handle_SD.cpp Handle_XFS.cpp Handle_XBox360Sim.cpp Handle_IMU.cpp Handle_CPUInfo.cpp
  group Modle
    ./Modle/: ModleManager.cpp ModlePrivate.h
  group LuaScript
    ./LuaScript/: LuaBasic.cpp LuaCom.cpp LuaGPIO.cpp LuaGUI.cpp LuaModuleCtrl.cpp LuaMouseKeyboard.cpp LuaScript.cpp LuaTime.cpp
  group lua-5.3.2
    ../Libraries/lua-5.3.2/src/: lapi.c lauxlib.c lbaselib.c lbitlib.c lcode.c lcorolib.c lctype.c ldblib.c ldebug.c ldo.c ldump.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c loslib.c lparser.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lundump.c lutf8lib.c lvm.c lzio.c
  group FileSystem
    ../Libraries/SdFat/src/FatLib/: FatFile.cpp FatFileLFN.cpp FatFilePrint.cpp FatFileSFN.cpp FatVolume.cpp FmtNumber.cpp fstream.cpp istream.cpp ostream.cpp StdioStream.cpp
    ../Libraries/SdFat/src/SdCard/: SdSpiCard.cpp SdSpiCardEX.cpp
    ../Libraries/SdFat/src/SpiDriver/: SdSpiSTM32.cpp
    ../Libraries/SdFat/src/: MinimumSerial.cpp
  group Game/Hopper
    ./Game/hopper/: game.cpp hopper.cpp logo.cpp MyArduboy.cpp title.cpp
  group Game/doom-nano
    ./Game/doom-nano/: doom-nano.cpp entities.cpp input.cpp types.cpp
  group Arduboy
    ../Libraries/Arduboy/: Arduboy.cpp
    ../Libraries/Arduboy/audio/: audio.cpp
    ../Libraries/Arduboy/core/: core.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/TFT_SSD1283A/: TFT_SSD1283A.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/BV_Player/: BV_Player.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EEPROM_File/: EEPROM_File.cpp
    ../Libraries/I2Cdev/: I2Cdev.cpp
    ../Libraries/MPU6050/: MPU6050.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/NRF/: NRF_Basic.cpp NRF_TRM.cpp NRF_FHSS.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/SoftwareSPI/: SoftwareSPI.cpp
    ../Libraries/StrPrinter/: StrPrinter.cpp
    ../Libraries/XFS/: XFS.cpp
    ../Libraries/WavDecoder/: wav_decoder.cpp
    ../Libraries/cm_backtrace/: cm_backtrace.c
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c itoa.c Print.cpp HardwareSerial.cpp SPI.cpp Stream.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp Tone.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c timer.c rng.c
    ../CORE/: delay.c pwm.c
  group README
    ../: README.md
software components: CMSIS:CORE 5.2.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:DMA 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RNG 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SDIO 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
