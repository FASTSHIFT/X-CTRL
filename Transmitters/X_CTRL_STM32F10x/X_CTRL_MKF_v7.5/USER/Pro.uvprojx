# Keil uVision project Pro.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pro
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DERIVER,ARDUINO=111
  c include: ..\USER;..\ArduinoAPI;..\Core;..\Libraries\I2Cdev;..\Libraries\MPU6050;..\Libraries\NRF;..\Libraries\Adafruit_GFX_Library;..\Libraries\MillisTaskManager;..\Libraries\DigitalFilter;..\Libraries\EncoderEvent;.\GUI;.\GUI\Bitmap;..\Libraries\Bluetooth_HC05;..\Libraries\ButtonEvent;.\Handler;.\Basic;..\Libraries\EEPROM;..\Libraries\Adafruit_GFX_Library\Fonts;..\Libraries\XFS;..\Libraries\FifoQueue;.\Handle;..\Libraries\LightGUI;..\Libraries\LightGUI\Engine3D;..\Libraries\LightGUI\MenuManager;..\Libraries\LightGUI\PageManager;..\Libraries\MusicPlayer;..\Libraries\BV_Player;..\Libraries\SD\src;..\Libraries\SoftwareSPI;..\Libraries\lua-5.3.2\src;.\LuaCtrl;..\Libraries\StrPrinter;.\Game\hopper;..\Libraries\Arduboy;..\Libraries\Adafruit_ST7735_Library
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group ArduinoAPI
    ../ArduinoAPI/: Arduino.c dtostrf.c HardwareSerial.cpp itoa.c Print.cpp WString.cpp Wire.cpp WireBase.cpp WMath.cpp SPI.cpp Stream.cpp Tone.cpp
  group Libraries
    ../Libraries/Adafruit_GFX_Library/: Adafruit_GFX.cpp
    ../Libraries/Adafruit_ST7735_Library/: Adafruit_ST7735.cpp
    ../Libraries/Bluetooth_HC05/: Bluetooth_HC05.cpp
    ../Libraries/ButtonEvent/: ButtonEvent.cpp
    ../Libraries/EEPROM/: EEPROM.cpp
    ../Libraries/EncoderEvent/: EncoderEvent.cpp
    ../Libraries/LightGUI/MenuManager/: MenuManager.cpp
    ../Libraries/LightGUI/PageManager/: PageManager.cpp
    ../Libraries/MillisTaskManager/: MillisTaskManager.cpp
    ../Libraries/MusicPlayer/: MusicPlayer.cpp
    ../Libraries/NRF/: NRF.cpp
    ../Libraries/StrPrinter/: StrPrinter.cpp
    ../Libraries/XFS/: XFS.cpp
  group Core
    ../Core/: adc.c exti.c gpio.c pwm.c timer.c
    ../CORE/: delay.c
  group Basic
    ./Basic/: main.cpp Initialization.cpp SensorRead.cpp ComBasic.cpp ComHandshake.cpp
  group GUI
    ./GUI/: DisplayBasic.cpp DisplayStatusBar.cpp DrawBitmap.cpp Page_EXAMPLE.cpp Page_About.cpp Page_CtrlInfo.cpp Page_FreqGraph.cpp Page_Game.cpp Page_Handshake.cpp Page_MainMenu.cpp Page_Options.cpp Page_SetBluetooth.cpp Page_SetJoystick.cpp
  group Handle
    ./Handle/: Handle_ButtonEvent.cpp Handle_Buzz.cpp Handle_DataStorage.cpp Handle_EncoderEvent.cpp Handle_PowerCtrl.cpp Handle_XFS.cpp
  group Arduboy_FW
    ../Libraries/Arduboy/: Arduboy.cpp
    ../Libraries/Arduboy/core/: core.cpp
    ../Libraries/Arduboy/audio/: audio.cpp
  group Game_Hopper
    ./Game/hopper/: game.cpp hopper.cpp logo.cpp MyArduboy.cpp title.cpp
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
